options:
  parameters:
    author: Scott Elliott
    category: Custom
    generate_options: qt_gui
    id: IEEE_802_15_4_Wireshark
    output_language: python
    realtime_scheduling: '1'
    title: IEEE 802.15.4 to Wireshark
  states: {}

blocks:
- name: CH
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 99,0,1,1
    label: 802.15.4 Channel
    label0: '24'
    label1: '25'
    label2: '26'
    label3: '11'
    label4: '12'
    num_opts: '5'
    option0: '"Ch24"'
    option1: '"Ch25"'
    option2: '"Ch26"'
    option3: '"Ch11"'
    option4: '"Ch12"'
    orient: Qt.QHBoxLayout
    type: raw
    value: '"Ch24"'
    widget: radio_buttons
  states: {}
- name: ComFreqStruct
  id: variable_qtgui_chooser
  parameters:
    label: Frequency
    labels: '["Ch11","Ch12","Ch13","Ch14","Ch15","Ch16","Ch17","Ch18","Ch19","Ch20","Ch21","Ch22","Ch23","Ch24","Ch25","Ch26"]'
    num_opts: '0'
    options: '[2.405,2.41,2.415,2.42,2.425,2.43,2.435,2.44,2.445,2.45,2.455,2.46,2.465,2.47,2.475,2.48]'
    type: real
    value: '2.405'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 98,0,1,1
    label: BB
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: comm_freq_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 99,1,1,1
    label: 'Com Freq:'
    type: real
    value: freq
  states: {}
- name: freq
  id: variable
  parameters:
    value: ComFreqStruct * 1000000000
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 97,0,1,1
    label: if_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 96,0,1,1
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sensor.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.basic_block):\n    \"\"\"Convert Zigbee Link Quality Indicator (LQI) (0..255) \n       to RFtap signal quality field (qual) (0.0..1.0)\"\"\"\n\n    def __init__(self):\n        gr.basic_block.__init__(\n            self,\n            name='LQI to qual',   # will show up in GRC\n            in_sig=[],\n            out_sig=[]\n        )\n        self.message_port_register_in(pmt.intern('in'))\n        self.set_msg_handler(pmt.intern('in'), self.handle_msg)\n        self.message_port_register_out(pmt.intern('out'))\n\n    def handle_msg(self, pdu):\n        meta, data = pmt.to_python(pdu)\n        meta['qual'] = meta['lqi'] / 255.0\n        pduout = pmt.cons(pmt.to_pmt(meta), pmt.to_pmt(data))\n        self.message_port_pub(pmt.intern('out'), pduout)\n\n"
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: ieee802_15_4_packet_sink_0
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import ieee802_15_4
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: from math import sin, pi
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52006'
    type: UDP_CLIENT
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'WireShark/FIle SInk is for off line only '
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52006'''
  states: {}
- name: note_2
  id: note
  parameters:
    note: 'PDU/RFtap is for live connection to Wireshark '
  states: {}
- name: note_3
  id: note
  parameters:
    note: Port number is is ised in wireshark.  On OSX, you can not reuse a port number without rebooting due to an apparent bug
  states: {}
- name: note_4
  id: note
  parameters:
    note: In RFtap ENcap wpan is used to indicate 802.15.4/zigbee
  states: {}
- name: note_5
  id: note
  parameters:
    note: This is setup for a Lime SDR, adjust as needed
  states: {}
- name: note_6
  id: note
  parameters:
    note: QT only support 5 options in choose
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: LNAH
    args: soapy=0,driver=lime
    bb_gain0: bb_gain
    freq0: freq
    gain0: rx_gain
    gain_mode0: 'True'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.to_pmt("nomfreq")
    v: pmt.intern("value")
  states: {}
- name: qtgui_const_sink_x_1_1
  id: qtgui_const_sink_x
  parameters:
    color1: '"Dark Blue"'
    gui_hint: 1,0,1,4
    label1: Rx raw
    marker1: '9'
    name: '"Rx"'
    size: '1024'
    style1: '1'
    tr_level: '0.4'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
    xmax: '0.4'
    xmin: '-0.4'
    ymax: '0.4'
    ymin: '-0.4'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 5,0,1,4
    label1: Raw DC Blocked R
    label2: Raw DC Blocked I
    name: '"Rx"'
    size: '1024'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/2
    fc: freq
    fftsize: '1024'
    gui_hint: 7,0,1,4
    label1: Raw
    name: '"raw"'
    showports: 'True'
    type: complex
  states: {}
- name: rftap_rftap_encap_0
  id: rftap_rftap_encap
  parameters:
    custom_dissector_name: wpan
    custom_dlt: '-1'
    encapsulation_from: '3'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: rx_gain+if_gain+bb_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sdr
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sdr
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [dc_blocker_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [dc_blocker_xx_0, '0', qtgui_const_sink_x_1_1, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_1, '0']
- [dc_blocker_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', ieee802_15_4_packet_sink_0, '0']
- [epy_block_0, out, pdu_pdu_set_0, pdus]
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_packet_sink_0, out, blocks_message_debug_1_0, print_pdu]
- [ieee802_15_4_packet_sink_0, out, epy_block_0, in]
- [ieee802_15_4_packet_sink_0, out, foo_wireshark_connector_0, in]
- [osmosdr_source_0, '0', virtual_sink_0, '0']
- [pdu_pdu_set_0, pdus, rftap_rftap_encap_0, in]
- [rftap_rftap_encap_0, out, network_socket_pdu_0, pdus]
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-395-g4f3dd2f4
